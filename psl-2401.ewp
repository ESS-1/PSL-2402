# IAR project psl-2401.ewp, settings and files
configuration PSL-2401 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100x8 ST STM32F100x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD_VL; PSL2401
  ICCARM.CCIncludePath2: Source\Sys\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: psl-2401.hex
  ILINK.IlinkOutputFile: psl-2401.out
  ILINK.IlinkIcfFile: psl-2401.icf
  ILINK.IlinkExtraOptions: --basic_heap
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration PSL-2402 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F10X_MD_VL; PSL2402
  OBJCOPY.OOCOutputFile: psl-2402.hex
  ILINK.IlinkOutputFile: psl-2402.out
  group App
    Source/: analog.cpp control.cpp data.cpp display.cpp eeprom.cpp encoder.cpp fan.cpp i2csw.cpp keyboard.cpp main.cpp menu.cpp port.cpp sound.cpp sreg.cpp systimer.cpp therm.cpp wake.cpp wakeport.cpp
  group Sys
    Source/Sys/: startup_stm32f10x_md_vl.s stm32f10x.h
